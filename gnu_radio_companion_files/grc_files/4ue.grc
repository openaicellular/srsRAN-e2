options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2100
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2010
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_1_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2110
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_1_0_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:3000
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_2
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2000
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2011
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2111
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:3001
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_1
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2001
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_3
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2101
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_add_xx_0, '0', zeromq_rep_sink_0, '0']
- [zeromq_req_source_0, '0', blocks_add_xx_0, '1']
- [zeromq_req_source_0_0, '0', blocks_add_xx_0, '2']
- [zeromq_req_source_0_0_0, '0', blocks_add_xx_0, '3']
- [zeromq_req_source_1, '0', blocks_add_xx_0, '0']
- [zeromq_req_source_3, '0', zeromq_rep_sink_1, '0']
- [zeromq_req_source_3, '0', zeromq_rep_sink_1_0, '0']
- [zeromq_req_source_3, '0', zeromq_rep_sink_1_0_0, '0']
- [zeromq_req_source_3, '0', zeromq_rep_sink_2, '0']

metadata:
  file_format: 1
